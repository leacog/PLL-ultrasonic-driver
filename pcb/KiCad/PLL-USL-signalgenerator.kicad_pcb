# Repository leacog/PLL-ultrasonic-driver

File README.md:

# PLL-ultrasonic-driver
KiCad project files and arduino code for an in-expensive and simple phase-locked-loop driver for piezo-electric ultrasonic transducers. 

### Principle of operation
The driver exploits the fact that, at resonance, current and voltage is in phase for a piezoelectric transducer. By locking the driving signal to the current feedback signal, i.e. adjust the driving frequency until it is in-phase with the current, resonance of the transducer can be found. 

The driver is based around the CD4046 Phase Locked Loop (PLL) IC (Texas instruments has a good application report: http://www.ti.com/lit/an/scha002a/scha002a.pdf) and an arduino nano. The driver features two modes of operation:

### Automatic resonance tracing (PLL mode) ###
A current sensing resistor provides a reference signal which is compared to the driving signal at the phase demodulator of the CD4046. Before being fed into the phase-demodulator however, the current signal is put through a comparator which turns the analog signal into a digital signal (positive cycle of the AC-waveform becomes high while the negative cycle becomes 0V). This retains phase information and gives better lock performace than the unaltered current-signal. The phase demodulator output is low-pass filtered and feed as the input to the voltage controlled oscillator(VCO), the output of which is the driving signal.

### Digital control (Arduino mode) ###
In digital mode, instead of feeding the output of the phase-demodulator into the VCO, a low-pass filtered PWM signal from the arduino is feed as an input. The dutycycle determines the voltage at the VCO input and thus the driving frequency. Since the driver can be interfaced via a serial-connection to a PC, this can be programmed to do perform any arbitrary function. One use-case is to do impedance-analysis of the transducer.

This is possible because the arduino monitors the current. The current signal, around 100mV from the current sensing resistor, is amplified by a non-inverting op-amp and sent through a simple peak detection circuit. This voltage is read by the arduino, which can use it to emulate the PLL or send to the PC over serial. 

### Selecting frequency ###
There are two main parameters of concern with regards to tuning the driver for the right frequncy. The **center frequency** and the **frequency lock range**. The latter is the bandwidht of the driver i.e. the difference between the lowest and the highest frequency it can output. A large bandwidth provides a large operating range for the transducers, however there's a tradeoff between large bandwidth and the abillity of the driver to aquire lock and the size of the phase error at lock (the undesired difference in phase). The center frequency is  the frequncy halfwaybetween the maximum and the minumum operating frequncy. In the case of a standard 60W 25KHz transducer a suitiable center frequency is 25 KHz with a lock range of 1 KHz (i.e. the signal can vary between 24.5 to 25.5 KHz).

These parameters are tuned through a frequncy selector network. A switch selects the center frequency, either of 40 or 25 KHz (programmable by resistors), which can be fine-tuned with a variable resistor. The lock range is set by another variable resistor.

## KiCad design pcb/KiCad/PLL-USL-signalgenerator.kicad_pcb

File pcb/README.md:

This directory contains the final artwork used for the pcb. If you wish to edit/improve the design all KiCad project files are provided as well.

NOTE: external footprint libraries are used for many component which likely will result in erros unless you have them all installed. The easiest way to solve this is by editing the footprints in the netlist. Beware that footprints aren't automatically swaped, the footprint accosiation is only updated once the old footprints have been deleted from the board and the netlist. (I advise to double-check that the pinouts for changed footprints are correct!)

Parts:
25K/40K-FreqSelct1: 25K/40K; SW_SPDT_CK-JS102011SAQN
25K/40K-FreqSelct2: Arduino/PLL; SW_SPDT_CK-JS102011SAQN
C1-4046Decoupling1, C1-NAND-Decoupling1, C1-OpAmpDecoupling1, C1-PeakDetector1: 100nF; C_0805
C1-LockDetctLPF1, C1-VCOinLPF1: 10nF; C_0805
C1-PWM-LPF1: 1uF; C_0805
D1-LockDetectionIndication1: GREEN; LED_0805
D1-PeakDetector1: D; SOT-23-PinCorrection
J1: CurrentSigIn; mpt_05-2f2-254
J2: Screw_Terminal_1x03; mpt_05-2f3-254
J3: SJ-43514-SMT-TR; SJ-43514-SMT_3.5mm_Jack
P1: CONN_01X03; Socket_Strip_Straight_1x03_Pitch2.54mm
P2: USB_OTG; USB_Mini-B_Handsoldering
R1-FreqSelct25K1, R1-GainOpAmp1, R1-PWM-LPF1, R2-FreqSelct40K1: 15K; R_0805
R1-LockDetctLPF1, R1-VCOinLPF1: 120K; R_0805
R1-LockDetectionIndication1: 470; R_0805
R1-OffsetInput1: 1k; R_0805
R2-OffsetInput1: 330k; R_0805
ReserveCap1: 100uF; CP_Elec_6.3x5.3
Rf-GainOpAmp1: 220K; R_0805
TimingCap1: 1.5nF; C_0805
U1: Arduino-Nano; Arduino-Nano-Pinheader
U1-PLL1: 4046USL; TSSOP-16-SMALLPADS
U2: TLV3542; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: 74HC00; SO14
U4: 126x64-OLED-SPI-4W; OLED1.3inch7pinSPI
VR1-FreqSelctRange1: 1M; trim_murata_pva2a
VR2-FreqSelct5K1: 5K; trim_bi_23b

Connections:
CurrentWaveform: D1-PeakDetector1.2 (A), Rf-GainOpAmp1.2, U2.1
GND: 25K/40K-FreqSelct1.1, C1-4046Decoupling1.2, C1-LockDetctLPF1.2, C1-NAND-Decoupling1.2, C1-OpAmpDecoupling1.2, C1-PWM-LPF1.2, C1-PeakDetector1.2, C1-VCOinLPF1.2, J1.2, J2.2, J3.1 (GND), P1.2, P2.5 (GND), P2.6 (shield), R1-FreqSelct25K1.1, R1-GainOpAmp1.2, R1-LockDetectionIndication1.2, ReserveCap1.1, U1.4 (GND), U1.29 (GND), U1-PLL1.5 (Inh), U1-PLL1.8 (VSS(GND)), U2.4 (V-), U2.6 (-), U3.7 (GND), U4.1 (GND), VR1-FreqSelctRange1.2
Lock: D1-LockDetectionIndication1.2 (A), U1.6 (D3), U3.8
Mic: J3.4 (Mic)
unnamed: 25K/40K-FreqSelct1.2, R2-FreqSelct40K1.1
unnamed: 25K/40K-FreqSelct1.3, R1-FreqSelct25K1.2
unnamed: 25K/40K-FreqSelct2.1, C1-VCOinLPF1.1, R1-VCOinLPF1.2
unnamed: 25K/40K-FreqSelct2.2, U1-PLL1.9 (VCOin)
unnamed: C1-LockDetctLPF1.1, R1-LockDetctLPF1.2, U3.9, U3.10
unnamed: C1-PeakDetector1.1, D1-PeakDetector1.1 (K), U1.19 (A0)
unnamed: D1-LockDetectionIndication1.1 (K), R1-LockDetectionIndication1.1
unnamed: J1.1, R1-OffsetInput1.1, U2.5 (+)
unnamed: J2.3, J3.2 (R), P1.3, U3.11
unnamed: R1-GainOpAmp1.1, Rf-GainOpAmp1.1, U2.2 (-)
unnamed: R1-LockDetctLPF1.1, U3.6
unnamed: R1-OffsetInput1.2, R2-OffsetInput1.2, U2.3 (+)
unnamed: R1-PWM-LPF1.1, U1.9 (D6)
unnamed: R1-VCOinLPF1.1, U1-PLL1.13 (PC2out)
unnamed: R2-FreqSelct40K1.2, VR2-FreqSelct5K1.2
unnamed: TimingCap1.1, U1-PLL1.6 (C1)
unnamed: TimingCap1.2, U1-PLL1.7 (C2)
unnamed: U1-PLL1.1 (PCP), U3.1, U3.2
unnamed: U1-PLL1.2 (PC1out), U3.5
unnamed: U1-PLL1.11 (R1), VR1-FreqSelctRange1.1
unnamed: U1-PLL1.12 (R2), VR2-FreqSelct5K1.1
unnamed: U1-PLL1.14 (SIGin), U2.7
unnamed: U1.11 (D8), U4.5 (RST)
unnamed: U1.12 (D9), U4.6 (DC)
unnamed: U1.13 (D10), U4.7 (CS)
unnamed: U1.14 (D11), U4.4 (MOSI)
unnamed: U1.16 (D13), U4.3 (CLK)
unnamed: U3.3, U3.4
PWM-LPF: 25K/40K-FreqSelct2.3, C1-PWM-LPF1.1, R1-PWM-LPF1.2
Tone: J2.1, J3.3 (L), P1.1, U1.8 (D5), U1-PLL1.3 (COMPin), U1-PLL1.4 (VCOout), U3.12, U3.13
VCC: C1-4046Decoupling1.1, C1-NAND-Decoupling1.1, C1-OpAmpDecoupling1.1, P2.1 (VBUS), R2-OffsetInput1.1, ReserveCap1.2, U1.30 (Vin), U1-PLL1.16 (VDD), U2.8 (V+), U3.14 (VCC), U4.2 (Vcc)

Notes on the sheet:
Frequency selector/tuning network
Current signal amplification
Inverter
Signal output
Lock detection indication
Lock detection
LPF-VCOin

Board: 2 copper layers, 60.0 x 69.0 mm, 35 parts (0 on the bottom side), 34 nets.

## Commit log

2018-02-04 Create Discription
2018-02-04 Create artwork
2018-02-04 Create what
2018-02-04 Update and rename what to freqCounterOLED
2018-02-04 Create python-serial-interface
    The core idea of this python sketch is to use the serial module to interface the computer and the driver. This is mainly for logging current and frequency measurements. But the driver can also be con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
    NOTE: I'm completely inexperienced with python so please don't expect this to work on your machine without small to severe adjustments (for example the serial port paths will be different if you're n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
2018-02-04 Update python-serial-interface
2018-02-05 Rename Discription to README.md
2018-02-09 Update freqCounterOLED
